Properties of the parts of a building model (IFC4)

# File
Description: Raumtemperaturregler mit Temperaturanzeige, Aufputz superflach, 5…30 °C, 230 VAC, 3(0,5) A, Schließer, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MA700800, Raumtemperaturregler mit Temperaturanzeige, Aufputz superflach, 5…30 °C, 230 VAC, 3(0,5) A, Schließer
In: Raum
Description: Dieser Raumtemperaturregler wurde speziell für die Regelung oder Überwachung von Temperaturen in Büros, Wohnräumen und Hotels entwickelt und ist zum direkten Anschluss von bis zu 10 Ventilantrieben (stromlos geschlossen) für Warmwasserheizungen geeignet. Im Normalbetrieb ist die Anzeige deaktiviert. Durch Berühren einer Tastfläche wird die aktuelle Raumtemperatur angezeigt. Wird während dieser Anzeige eine Tastfläche berührt, kann die gewünschte Solltemperatur in 1 °C Schritten verstellt werden.; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MA700800; ModelLabel: HTRRBd-210.100; GlobalTradeItemNumber: 4050528077080; ProductURL: https://alre.de/produkt_MA700800
Pset_Specification - NominalLength: 0.0785 m; NominalWidth: 0.078 m; NominalDepth: 0.0139 m; NetWeight: 0.0518
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: weiß; Breite: 78; Höhe: 78.5; Tiefe: 13.9; RAL-Nummer: 9010; Anschluss: drei-/vieradrig; Art der Spannungsversorgung: 230 V AC; Kontaktausführung: Schließer (NO); Messbereich: 5; Bedienung: Taste; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Widerstandssensor; Klasse des Temperaturreglers: IV; Leistungsaufnahme im Bereitschaftszustand (solstandby): 0.5; Schutzart (NEMA): sonstige; Verdeckte Bedienung: no; Max. Spannung der Kontakte: 230; Mit Empfänger: no; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 0; Temperatur ablesbar: yes; Max. Kontaktbelastung: 3; Differenzwert: 0.5; Sensor extern: no; Thermische Rückkopplung: ohne; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: no; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MA700800.pdf
